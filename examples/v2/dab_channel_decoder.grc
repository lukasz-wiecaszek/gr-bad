options:
  parameters:
    author: Łukasz Więcaszek
    generate_options: qt_gui
    id: dab_channel_decoder
    output_language: python
    title: DAB channel  decoder
  states: {}

blocks:
- name: freq_offset
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '-1000'
    step: '10'
    stop: '+1000'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2048000'
  states: {}
- name: bad_fic_decoder_0
  id: bad_fic_decoder
  parameters: {}
  states: {}
- name: bad_frequency_deinterleaver_0
  id: bad_frequency_deinterleaver
  parameters: {}
  states: {}
- name: bad_msc_decoder_0
  id: bad_msc_decoder
  parameters:
    protection_level: '2'
    subch_size: '72'
    subch_start_addr: '618'
    table_index: ''
    type: bad.PROTECTION_TYPE_EEP_A
  states: {}
- name: bad_ns_detector_0
  id: bad_ns_detector
  parameters: {}
  states: {state: disabled}
- name: bad_ns_detector_1
  id: bad_ns_detector
  parameters: {}
  states: {}
- name: bad_ofdm_coarse_frequency_correction_0
  id: bad_ofdm_coarse_frequency_correction
  parameters: {}
  states: {}
- name: bad_ofdm_differential_demodulator_0
  id: bad_ofdm_differential_demodulator
  parameters: {}
  states: {}
- name: bad_ofdm_fine_frequency_correction_0
  id: bad_ofdm_fine_frequency_correction
  parameters:
    alpha: '0.1'
  states: {}
- name: bad_ofdm_sampler_0
  id: bad_ofdm_sampler
  parameters: {}
  states: {}
- name: bad_ofdm_symbols_selector_0
  id: bad_ofdm_symbols_selector
  parameters:
    count: '3'
    first: '1'
  states: {}
- name: bad_ofdm_symbols_selector_0_0
  id: bad_ofdm_symbols_selector
  parameters:
    count: '72'
    first: '4'
  states: {}
- name: bad_qpsk_symbol_demapper_0
  id: bad_qpsk_symbol_demapper
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: fic.dat
    type: byte
  states: {}
- name: blocks_file_sink_0_0_0
  id: blocks_file_sink
  parameters:
    file: msc.fifo
    type: byte
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '1536'
    type: complex
  states: {}
- name: blocks_vector_to_stream_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '2048'
    type: complex
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: '2048'
    forward: 'True'
    shift: 'True'
    type: complex
    window: '[]'
  states: {}
- name: qtgui_const_sink_x_1
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
    xmax: '200'
    xmin: '-200'
    ymax: '200'
    ymin: '-200'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '2048'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: 2048*5
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_1_0
  id: qtgui_time_sink_x
  parameters:
    size: 2048*96*2
    srate: samp_rate
    type: float
    ymax: 1 * 3.1415 / 2048
    ymin: '-1  * 3.1415 / 2048'
  states: {}
- name: rtlsdr_source_0_0
  id: rtlsdr_source
  parameters:
    args: ''
    bb_gain0: '20'
    freq0: '218640000'
    gain0: '30'
    gain_mode0: 'True'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [bad_fic_decoder_0, '0', blocks_file_sink_0, '0']
- [bad_frequency_deinterleaver_0, '0', bad_qpsk_symbol_demapper_0, '0']
- [bad_msc_decoder_0, '0', blocks_file_sink_0_0_0, '0']
- [bad_ns_detector_1, '0', bad_ofdm_fine_frequency_correction_0, '0']
- [bad_ofdm_coarse_frequency_correction_0, '0', bad_ofdm_differential_demodulator_0, '0']
- [bad_ofdm_differential_demodulator_0, '0', bad_frequency_deinterleaver_0, '0']
- [bad_ofdm_differential_demodulator_0, '0', blocks_vector_to_stream_0, '0']
- [bad_ofdm_fine_frequency_correction_0, '0', bad_ofdm_sampler_0, '0']
- [bad_ofdm_fine_frequency_correction_0, '1', qtgui_time_sink_x_1_0, '0']
- [bad_ofdm_sampler_0, '0', fft_vxx_0, '0']
- [bad_ofdm_symbols_selector_0, '0', bad_fic_decoder_0, '0']
- [bad_ofdm_symbols_selector_0_0, '0', bad_msc_decoder_0, '0']
- [bad_qpsk_symbol_demapper_0, '0', bad_ofdm_symbols_selector_0, '0']
- [bad_qpsk_symbol_demapper_0, '0', bad_ofdm_symbols_selector_0_0, '0']
- [blocks_complex_to_mag_squared_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_vector_to_stream_0, '0', qtgui_const_sink_x_1, '0']
- [blocks_vector_to_stream_0_0, '0', blocks_complex_to_mag_squared_0, '0']
- [fft_vxx_0, '0', bad_ofdm_coarse_frequency_correction_0, '0']
- [fft_vxx_0, '0', blocks_vector_to_stream_0_0, '0']
- [rtlsdr_source_0_0, '0', bad_ns_detector_0, '0']
- [rtlsdr_source_0_0, '0', bad_ns_detector_1, '0']
- [rtlsdr_source_0_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
